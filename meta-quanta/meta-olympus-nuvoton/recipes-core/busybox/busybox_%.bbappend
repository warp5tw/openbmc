FILESEXTRAPATHS_prepend_nuvoton := "${THISDIR}/${PN}:"
SRC_URI_append_nuvoton = " file://busybox.cfg"
