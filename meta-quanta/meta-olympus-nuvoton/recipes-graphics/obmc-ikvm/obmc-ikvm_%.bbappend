LIC_FILES_CHKSUM = "file://LICENSE;md5=d32239bcb673463ab874e80d47fae504"

SRC_URI = "git://github.com/Nuvoton-Israel/obmc-ikvm"
SRCREV = "2c8dd31604d46f18067689f473b568bbefdb38df"
