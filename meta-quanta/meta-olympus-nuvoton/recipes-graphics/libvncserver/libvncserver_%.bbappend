PACKAGECONFIG_append_olympus-nuvoton = " ipv6"
