UBOOT_MAKE_TARGET_append_olympus-nuvoton = " DEVICE_TREE=${UBOOT_DEVICETREE}"

