FILESEXTRAPATHS_append_olympus-nuvoton := "${THISDIR}/${PN}:"

SRCREV = "2cdc49585235a6557c9cbb6c8b75c064fc02681a"
SRC_URI_append_olympus-nuvoton = " file://0001-olympus-kcsbridged.patch"

