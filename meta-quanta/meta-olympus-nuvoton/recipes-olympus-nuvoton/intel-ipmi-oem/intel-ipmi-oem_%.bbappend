FILESEXTRAPATHS_prepend_olympus-nuvoton := "${THISDIR}/files:"
SRC_URI_append_olympus-nuvoton = " file://0001-support-psu-manager.patch"

SRCREV = "849c319f95bfc5b76b1731cadbf95c24093aa53c"
