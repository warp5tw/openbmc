SRC_URI_olympus-nuvoton := "git://github.com/Nuvoton-Israel/pmci.git;protocol=ssh"
SRCREV_olympus-nuvoton := "6fe3d2677320c391aed5c6d61af38ed43b508e62"
