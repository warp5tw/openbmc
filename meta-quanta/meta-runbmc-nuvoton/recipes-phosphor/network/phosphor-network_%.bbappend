EXTRA_OECONF_runbmc-nuvoton += " --disable-link-local-autoconfiguration"
