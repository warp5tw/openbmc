PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " runbmc-nuvoton-yaml-config"
