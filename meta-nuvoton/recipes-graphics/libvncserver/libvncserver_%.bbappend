PACKAGECONFIG_append_nuvoton = " ipv6"
