LIC_FILES_CHKSUM = "file://LICENSE;md5=d32239bcb673463ab874e80d47fae504"

SRC_URI_nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm"
SRCREV_nuvoton := "023be8583560db29cce529845435325d13dc2d81"
