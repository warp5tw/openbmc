FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-pldmd-use-MCTP-kernel-socket.patch"
