FILESEXTRAPATHS_prepend_buv-runbmc := "${THISDIR}/${PN}:"
SRC_URI_append_buv-runbmc = " file://busybox.cfg"
