FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-libpldm-use-MCTP-kernel-socket.patch"
